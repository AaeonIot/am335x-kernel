## drivers/net/wireless/realtek/rtl88x2bu/Kconfig
```kconfig
config RTL8822BU
	tristate "Realtek 8822B USB WiFi"
	default y
	---help---
	  Help message of RTL8822BU
```
